options:
  parameters:
    author: Johannes Demel
    category: lte
    description: hierarchical block containing all parts of a linear LTE estimator
    generate_options: hb
    id: lte_channel_estimator
    output_language: python
    title: Channel Estimator
  states: {}

blocks:
- name: mymap
  id: variable
  parameters:
    value: lte.frame_pilot_value_and_position(N_rb_dl, initial_id, 1, 0)
  states: {}
- name: mymap1
  id: variable
  parameters:
    value: lte.frame_pilot_value_and_position(N_rb_dl, initial_id, 1, 0)
  states: {}
- name: poss0
  id: variable
  parameters:
    value: mymap[0]
  states: {}
- name: poss1
  id: variable
  parameters:
    value: mymap1[0]
  states: {}
- name: vals
  id: variable
  parameters:
    value: mymap[1]
  states: {}
- name: N_rb_dl
  id: parameter
  parameters:
    label: resource blocks
    type: intx
    value: '50'
  states: {}
- name: ain0
  id: pad_source
  parameters:
    label: in
    type: complex
    vlen: 12*N_rb_dl
  states: {}
- name: cell_id
  id: pad_source
  parameters:
    label: cell_id
    optional: 'True'
    type: message
  states: {}
- name: estimator_key
  id: parameter
  parameters:
    label: Tag Key
    value: '"slot"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import lte
  states: {}
- name: initial_id
  id: parameter
  parameters:
    label: initial Cell ID
    type: intx
    value: '0'
  states: {}
- name: lte_channel_estimator_vcvc_0
  id: lte_channel_estimator_vcvc
  parameters:
    msg_buf_name: ''
    name: ' "channel_estimator_vcvc"'
    pilot_carriers: poss0
    pilot_symbols: vals
    rxant: '1'
    subcarriers: 12*N_rb_dl
    tag_key: estimator_key
  states: {}
- name: lte_channel_estimator_vcvc_0_0
  id: lte_channel_estimator_vcvc
  parameters:
    msg_buf_name: ''
    name: ' "channel_estimator_vcvc"'
    pilot_carriers: poss1
    pilot_symbols: vals
    rxant: '1'
    subcarriers: 12*N_rb_dl
    tag_key: estimator_key
  states: {}
- name: ofdm_estimator_lte_rs_map_generator_m_0
  id: lte_rs_map_generator_m
  parameters:
    N_rb_dl: N_rb_dl
    ant_port: '0'
  states: {}
- name: ofdm_estimator_lte_rs_map_generator_m_1
  id: lte_rs_map_generator_m
  parameters:
    N_rb_dl: N_rb_dl
    ant_port: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out0
    type: complex
    vlen: 12*N_rb_dl
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out0
    type: complex
    vlen: 12*N_rb_dl
  states: {}

connections:
- [ain0, '0', lte_channel_estimator_vcvc_0, '0']
- [ain0, '0', lte_channel_estimator_vcvc_0_0, '0']
- [cell_id, out, ofdm_estimator_lte_rs_map_generator_m_0, cell_id]
- [cell_id, out, ofdm_estimator_lte_rs_map_generator_m_1, cell_id]
- [lte_channel_estimator_vcvc_0, '0', pad_sink_0, '0']
- [lte_channel_estimator_vcvc_0_0, '0', pad_sink_0_0, '0']
- [ofdm_estimator_lte_rs_map_generator_m_0, pilots, lte_channel_estimator_vcvc_0, pilots]
- [ofdm_estimator_lte_rs_map_generator_m_1, pilots, lte_channel_estimator_vcvc_0_0, pilots]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-128-gfa8953de
