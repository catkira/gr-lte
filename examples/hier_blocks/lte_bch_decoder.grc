options:
  parameters:
    author: Johannes Demel
    category: lte
    description: GR 3.7 hier block for LTE BCH decoding
    generate_options: hb
    id: lte_bch_decoder
    output_language: python
    title: BCH Decoder
  states: {}

blocks:
- name: data_len
  id: variable
  parameters:
    value: '24'
  states: {}
- name: final_xor1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: final_xor2
  id: variable
  parameters:
    value: '65535'
  states: {}
- name: final_xor4
  id: variable
  parameters:
    value: '21845'
  states: {}
- name: bch_blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: '3'
    type: float
  states: {}
- name: bch_blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: data_len
  states: {}
- name: bch_blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
    vlen: data_len
  states: {}
- name: bch_lte_bch_crc_check_ant_chooser_bb_0
  id: lte_bch_crc_check_ant_chooser_bb
  parameters:
    name: ' "bch_crc_check_ant_chooser_bb"'
  states: {}
- name: bch_lte_bch_viterbi_vfvb_0
  id: lte_bch_viterbi_vfvb
  parameters: {}
  states: {}
- name: bch_lte_crc_check_vbvb_0
  id: lte_crc_check_vbvb
  parameters:
    data_len: data_len
    final_xor: final_xor1
    name: ' "crc_check_vbvb"'
  states: {}
- name: bch_lte_crc_check_vbvb_1
  id: lte_crc_check_vbvb
  parameters:
    data_len: data_len
    final_xor: final_xor2
    name: ' "crc_check_vbvb"'
  states: {}
- name: bch_lte_crc_check_vbvb_2
  id: lte_crc_check_vbvb
  parameters:
    data_len: data_len
    final_xor: final_xor4
    name: ' "crc_check_vbvb"'
  states: {}
- name: bch_lte_subblock_deinterleaver_vfvf_0
  id: lte_subblock_deinterleaver_vfvf
  parameters:
    items_per_group: '1'
    name: ' "subblock_deinterleaver_vfvf"'
    num_groups: '40'
  states: {}
- name: bch_lte_subblock_deinterleaver_vfvf_1
  id: lte_subblock_deinterleaver_vfvf
  parameters:
    items_per_group: '1'
    name: ' "subblock_deinterleaver_vfvf"'
    num_groups: '40'
  states: {}
- name: bch_lte_subblock_deinterleaver_vfvf_2
  id: lte_subblock_deinterleaver_vfvf
  parameters:
    items_per_group: '1'
    name: ' "subblock_deinterleaver_vfvf"'
    num_groups: '40'
  states: {}
- name: bch_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    num_streams: '3'
    type: float
    vlen: '40'
  states: {}
- name: bch_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '120'
    type: float
  states: {}
- name: bch_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '3'
    type: float
    vlen: '40'
  states: {}
- name: bch_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '40'
    type: float
  states: {}
- name: bch_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '40'
    type: float
  states: {}
- name: bch_vector_to_stream_3
  id: blocks_vector_to_stream
  parameters:
    num_items: '40'
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: mib
    type: byte
    vlen: '24'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: N_ant
    type: byte
  states: {}
- name: pad_source
  id: pad_source
  parameters:
    label: in
    type: float
    vlen: '120'
  states: {}

connections:
- [bch_blocks_interleave_0, '0', bch_stream_to_vector_0, '0']
- [bch_lte_bch_crc_check_ant_chooser_bb_0, '0', pad_sink_1, '0']
- [bch_lte_bch_viterbi_vfvb_0, '0', bch_lte_crc_check_vbvb_0, '0']
- [bch_lte_bch_viterbi_vfvb_0, '0', bch_lte_crc_check_vbvb_1, '0']
- [bch_lte_bch_viterbi_vfvb_0, '0', bch_lte_crc_check_vbvb_2, '0']
- [bch_lte_crc_check_vbvb_0, '0', pad_sink_0, '0']
- [bch_lte_crc_check_vbvb_0, '1', bch_lte_bch_crc_check_ant_chooser_bb_0, '0']
- [bch_lte_crc_check_vbvb_1, '0', bch_blocks_null_sink_0, '0']
- [bch_lte_crc_check_vbvb_1, '1', bch_lte_bch_crc_check_ant_chooser_bb_0, '1']
- [bch_lte_crc_check_vbvb_2, '0', bch_blocks_null_sink_1, '0']
- [bch_lte_crc_check_vbvb_2, '1', bch_lte_bch_crc_check_ant_chooser_bb_0, '2']
- [bch_lte_subblock_deinterleaver_vfvf_0, '0', bch_vector_to_stream_1, '0']
- [bch_lte_subblock_deinterleaver_vfvf_1, '0', bch_vector_to_stream_2, '0']
- [bch_lte_subblock_deinterleaver_vfvf_2, '0', bch_vector_to_stream_3, '0']
- [bch_stream_to_streams_0, '0', bch_lte_subblock_deinterleaver_vfvf_0, '0']
- [bch_stream_to_streams_0, '1', bch_lte_subblock_deinterleaver_vfvf_1, '0']
- [bch_stream_to_streams_0, '2', bch_lte_subblock_deinterleaver_vfvf_2, '0']
- [bch_stream_to_vector_0, '0', bch_lte_bch_viterbi_vfvb_0, '0']
- [bch_vector_to_stream_0, '0', bch_stream_to_streams_0, '0']
- [bch_vector_to_stream_1, '0', bch_blocks_interleave_0, '0']
- [bch_vector_to_stream_2, '0', bch_blocks_interleave_0, '1']
- [bch_vector_to_stream_3, '0', bch_blocks_interleave_0, '2']
- [pad_source, '0', bch_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-128-gfa8953de
