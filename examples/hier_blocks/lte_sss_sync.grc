options:
  parameters:
    author: Johannes Demel
    category: lte
    description: hierarchical block including blocks for LTE SSS synchronization.
    generate_options: hb
    id: lte_sss_sync
    output_language: python
    title: LTE SSS Sync
  states: {}

blocks:
- name: N_rb_dl
  id: parameter
  parameters:
    label: resource blocks
    type: intx
    value: '50'
  states: {}
- name: fftlen
  id: parameter
  parameters:
    label: FFT length
    type: intx
    value: '2048'
  states: {}
- name: group_key
  id: parameter
  parameters:
    label: Cell ID group key
    value: '"N_id_2"'
  states: {}
- name: offset_key
  id: parameter
  parameters:
    label: offset marker key
    value: '"offset_marker"'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: cell_id
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: sync_sss_calculator_vcm_0
  id: lte_sss_calculator_vcm
  parameters:
    fftl: fftlen
    key_id: group_key
    key_offset: offset_marker
    name: ''
  states: {}
- name: sync_sss_extract_subcarriers_vcvc_0
  id: lte_extract_subcarriers_vcvc
  parameters:
    N_rb_dl: '6'
    fftl: fftlen
    name: ''
  states: {}
- name: sync_sss_fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftlen
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(fftlen)
  states: {}
- name: sync_sss_symbol_selector_cvc_0
  id: lte_sss_symbol_selector_cvc
  parameters:
    fftl: fftlen
    name: ''
  states: {}
- name: sync_sss_tagger_cc_0
  id: lte_sss_tagger_cc
  parameters:
    fftl: fftlen
    name: ''
  states: {}

connections:
- [pad_source_0, '0', sync_sss_symbol_selector_cvc_0, '0']
- [pad_source_0, '0', sync_sss_tagger_cc_0, '0']
- [sync_sss_calculator_vcm_0, cell_id, pad_sink_0_0, in]
- [sync_sss_calculator_vcm_0, frame_start, sync_sss_tagger_cc_0, frame_start]
- [sync_sss_extract_subcarriers_vcvc_0, '0', sync_sss_calculator_vcm_0, '0']
- [sync_sss_fft_vxx_0, '0', sync_sss_extract_subcarriers_vcvc_0, '0']
- [sync_sss_symbol_selector_cvc_0, '0', sync_sss_fft_vxx_0, '0']
- [sync_sss_tagger_cc_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-128-gfa8953de
