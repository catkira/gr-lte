options:
  parameters:
    author: Johannes Demel
    category: lte
    description: OFDM RX operations
    generate_options: hb
    id: lte_ofdm_demodulator
    output_language: python
    title: LTE OFDM Demodulator
  states: {}

blocks:
- name: N_rb_dl
  id: parameter
  parameters:
    label: resource blocks
    type: intx
    value: '50'
  states: {}
- name: fftlen
  id: parameter
  parameters:
    label: FFT length
    type: intx
    value: '2048'
  states: {}
- name: ofdm_fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftlen
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(fftlen)
  states: {}
- name: ofdm_key
  id: parameter
  parameters:
    label: Tag Key
    value: '"slot"'
  states: {}
- name: ofdm_lte_extract_subcarriers_vcvc_0
  id: lte_extract_subcarriers_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    fftl: fftlen
    name: ''
  states: {}
- name: ofdm_lte_remove_cp_cvc_0
  id: lte_remove_cp_cvc
  parameters:
    fftl: fftlen
    key: ofdm_key
    name: ' "remove_cp_cvc"'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
    vlen: 12*N_rb_dl
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [ofdm_fft_vxx_0, '0', ofdm_lte_extract_subcarriers_vcvc_0, '0']
- [ofdm_lte_extract_subcarriers_vcvc_0, '0', pad_sink_0, '0']
- [ofdm_lte_remove_cp_cvc_0, '0', ofdm_fft_vxx_0, '0']
- [pad_source_0, '0', ofdm_lte_remove_cp_cvc_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-128-gfa8953de
