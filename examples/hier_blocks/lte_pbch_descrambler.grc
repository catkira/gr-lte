options:
  parameters:
    author: Johannes Demel
    category: lte
    description: Block to descramble PBCH
    generate_options: hb
    id: lte_pbch_descrambler
    output_language: python
    title: PBCH Descrambler
  states: {}

blocks:
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import lte
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: '120'
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: float
    vlen: '480'
  states: {}
- name: pad_source_1_0
  id: pad_source
  parameters:
    label: cell_id
    type: message
  states: {}
- name: pbch_descr_blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
    vlen: '120'
  states: {}
- name: pbch_descr_blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/4.0]*120'
    type: float
    vlen: '120'
  states: {}
- name: pbch_descr_blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
    vlen: '1920'
  states: {}
- name: pbch_descr_blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '4'
    type: float
    vlen: '480'
  states: {}
- name: pbch_descr_blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[4, 1]'
    type: float
    vlen: '120'
  states: {}
- name: pbch_descr_blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    num_streams: '4'
    type: float
    vlen: '120'
  states: {}
- name: pbch_descr_blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '4'
    type: float
    vlen: '480'
  states: {}
- name: pbch_descr_blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '16'
    type: float
    vlen: '120'
  states: {}
- name: pbch_descr_repeat_message_source_vf_0
  id: lte_repeat_message_source_vf
  parameters:
    name: ' "repeat_message_source_vf"'
    vector_len: '1920'
  states: {}
- name: pbch_descr_scramble_sequencer_m_0
  id: lte_pbch_scramble_sequencer_m
  parameters:
    name: ''
  states: {}

connections:
- [pad_source_1, '0', pbch_descr_blocks_repeat_0, '0']
- [pad_source_1_0, out, pbch_descr_scramble_sequencer_m_0, cell_id]
- [pbch_descr_blocks_add_xx_0, '0', pbch_descr_blocks_multiply_const_vxx_0, '0']
- [pbch_descr_blocks_multiply_const_vxx_0, '0', pbch_descr_blocks_stream_mux_0, '1']
- [pbch_descr_blocks_multiply_xx_0, '0', pbch_descr_blocks_vector_to_stream_0, '0']
- [pbch_descr_blocks_repeat_0, '0', pbch_descr_blocks_stream_to_vector_0, '0']
- [pbch_descr_blocks_stream_mux_0, '0', pad_sink_0, '0']
- [pbch_descr_blocks_stream_to_streams_0, '0', pbch_descr_blocks_add_xx_0, '0']
- [pbch_descr_blocks_stream_to_streams_0, '1', pbch_descr_blocks_add_xx_0, '1']
- [pbch_descr_blocks_stream_to_streams_0, '2', pbch_descr_blocks_add_xx_0, '2']
- [pbch_descr_blocks_stream_to_streams_0, '3', pbch_descr_blocks_add_xx_0, '3']
- [pbch_descr_blocks_stream_to_vector_0, '0', pbch_descr_blocks_multiply_xx_0, '0']
- [pbch_descr_blocks_vector_to_stream_0, '0', pbch_descr_blocks_stream_mux_0, '0']
- [pbch_descr_blocks_vector_to_stream_0, '0', pbch_descr_blocks_stream_to_streams_0, '0']
- [pbch_descr_repeat_message_source_vf_0, '0', pbch_descr_blocks_multiply_xx_0, '1']
- [pbch_descr_scramble_sequencer_m_0, vector, pbch_descr_repeat_message_source_vf_0, vector]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-128-gfa8953de
