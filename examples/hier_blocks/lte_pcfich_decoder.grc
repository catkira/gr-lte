options:
  parameters:
    author: Johannes Demel
    category: lte
    description: hier block combining blocks and parameters to decode PCFICH
    generate_options: hb
    id: lte_pcfich_decoder
    output_language: python
    title: PCFICH Decoder
  states: {}

blocks:
- name: ants
  id: variable
  parameters:
    value: '2'
  states: {}
- name: style
  id: variable
  parameters:
    value: '"tx_diversity"'
  states: {}
- name: tag_key
  id: variable
  parameters:
    value: '"subframe"'
  states: {}
- name: vlen
  id: variable
  parameters:
    value: '16'
  states: {}
- name: N_rb_dl
  id: parameter
  parameters:
    label: resource blocks
    type: intx
    value: '50'
  states: {}
- name: key
  id: parameter
  parameters:
    label: Input key
    value: '"symbol"'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: CFI
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in0
    type: complex
    vlen: 12 * N_rb_dl
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in1
    type: complex
    vlen: 12 * N_rb_dl
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: in2
    type: complex
    vlen: 12 * N_rb_dl
  states: {}
- name: pcfich_demux_vcvc_0
  id: lte_pcfich_demux_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    key: key
    msg_buf_name: ''
    name: ' "pcfich_demux_vcvc"'
    out_key: tag_key
  states: {}
- name: pcfich_demux_vcvc_1
  id: lte_pcfich_demux_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    key: key
    msg_buf_name: ''
    name: ' "pcfich_demux_vcvc"'
    out_key: tag_key
  states: {}
- name: pcfich_demux_vcvc_2
  id: lte_pcfich_demux_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    key: key
    msg_buf_name: ''
    name: ' "pcfich_demux_vcvc"'
    out_key: tag_key
  states: {}
- name: pcfich_layer_demapper_vcvc_0
  id: lte_layer_demapper_vcvc
  parameters:
    N_ant: ants
    name: ' "layer_demapper_vcvc"'
    style: style
    vlen: vlen
  states: {}
- name: pcfich_lte_descrambler_vfvf_0
  id: lte_descrambler_vfvf
  parameters:
    initial_seqs: '[[0] * 32] * 10'
    tag_key: tag_key
    vlen: 2 * vlen
  states: {}
- name: pcfich_pre_decoder_vcvc_0
  id: lte_pre_decoder_vcvc
  parameters:
    N_ant: ants
    rxant: '1'
    style: style
    vlen: vlen
  states: {}
- name: pcfich_qpsk_soft_demod_vcvf_0
  id: lte_qpsk_soft_demod_vcvf
  parameters:
    name: ' "qpsk_soft_demod_vcvf"'
    vlen: vlen
  states: {}
- name: pcfich_scramble_sequencer_m_0
  id: lte_pcfich_scramble_sequencer_m
  parameters: {}
  states: {}
- name: pcfich_unpack_vfm_0
  id: lte_pcfich_unpack_vfm
  parameters:
    key: tag_key
    name: ' "pcfich_unpack_vfm"'
  states: {}
- name: z_pad_source_N_ant
  id: pad_source
  parameters:
    label: N_ant
    type: message
  states: {}
- name: z_pad_source_cell_id
  id: pad_source
  parameters:
    label: cell_id
    type: message
  states: {}

connections:
- [pad_source_0, '0', pcfich_demux_vcvc_0, '0']
- [pad_source_1, '0', pcfich_demux_vcvc_1, '0']
- [pad_source_2, '0', pcfich_demux_vcvc_2, '0']
- [pcfich_demux_vcvc_0, '0', pcfich_pre_decoder_vcvc_0, '0']
- [pcfich_demux_vcvc_1, '0', pcfich_pre_decoder_vcvc_0, '1']
- [pcfich_demux_vcvc_2, '0', pcfich_pre_decoder_vcvc_0, '2']
- [pcfich_layer_demapper_vcvc_0, '0', pcfich_qpsk_soft_demod_vcvf_0, '0']
- [pcfich_lte_descrambler_vfvf_0, '0', pcfich_unpack_vfm_0, '0']
- [pcfich_pre_decoder_vcvc_0, '0', pcfich_layer_demapper_vcvc_0, '0']
- [pcfich_qpsk_soft_demod_vcvf_0, '0', pcfich_lte_descrambler_vfvf_0, '0']
- [pcfich_scramble_sequencer_m_0, descr, pcfich_lte_descrambler_vfvf_0, seqs]
- [pcfich_unpack_vfm_0, CFI, pad_sink_0, in]
- [z_pad_source_N_ant, out, pcfich_layer_demapper_vcvc_0, N_ant]
- [z_pad_source_N_ant, out, pcfich_pre_decoder_vcvc_0, N_ant]
- [z_pad_source_cell_id, out, pcfich_scramble_sequencer_m_0, cell_id]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-128-gfa8953de
