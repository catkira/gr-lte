options:
  parameters:
    author: Johannes Demel
    category: lte
    description: hierarchical block to decode PBCH
    generate_options: hb
    id: lte_pbch_decoder
    output_language: python
    title: PBCH Decoder
  states: {}

blocks:
- name: pbch_descr_key
  id: variable
  parameters:
    value: '"descr_part"'
  states: {}
- name: style
  id: variable
  parameters:
    value: '"tx_diversity"'
  states: {}
- name: vlen
  id: variable
  parameters:
    value: '240'
  states: {}
- name: N_rb_dl
  id: parameter
  parameters:
    label: resource blocks
    type: intx
    value: '50'
  states: {}
- name: lte_pbch_demux_vcvc_0
  id: lte_pbch_demux_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    name: ' "pbch_demux_vcvc"'
    rxant: '1'
  states: {}
- name: lte_pbch_demux_vcvc_0_0
  id: lte_pbch_demux_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    name: ' "pbch_demux_vcvc"'
    rxant: '1'
  states: {}
- name: lte_pbch_demux_vcvc_0_1
  id: lte_pbch_demux_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    name: ' "pbch_demux_vcvc"'
    rxant: '1'
  states: {}
- name: lte_pbch_descrambler_0
  id: lte_pbch_descrambler
  parameters: {}
  states: {}
- name: lte_pre_decoder_vcvc_0
  id: lte_pre_decoder_vcvc
  parameters:
    N_ant: '1'
    rxant: '1'
    style: style
    vlen: vlen
  states: {}
- name: lte_pre_decoder_vcvc_1
  id: lte_pre_decoder_vcvc
  parameters:
    N_ant: '2'
    rxant: '1'
    style: style
    vlen: vlen
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: '120'
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: complex
    vlen: '240'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in0
    type: complex
    vlen: 12*N_rb_dl
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in1
    type: complex
    vlen: 12*N_rb_dl
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: in2
    type: complex
    vlen: 12*N_rb_dl
  states: {}
- name: pbch_blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
    vlen: vlen
  states: {}
- name: pbch_layer_demapper_vcvc_0
  id: lte_layer_demapper_vcvc
  parameters:
    N_ant: '1'
    name: ' "layer_demapper_vcvc"'
    style: style
    vlen: vlen
  states: {}
- name: pbch_layer_demapper_vcvc_1
  id: lte_layer_demapper_vcvc
  parameters:
    N_ant: '2'
    name: ' "layer_demapper_vcvc"'
    style: style
    vlen: vlen
  states: {}
- name: pbch_qpsk_soft_demod_vcvf_0
  id: lte_qpsk_soft_demod_vcvf
  parameters:
    name: ' "qpsk_soft_demod_vcvf"'
    vlen: vlen
  states: {}
- name: z_pad_source_cell_id
  id: pad_source
  parameters:
    label: cell_id
    type: message
  states: {}

connections:
- [lte_pbch_demux_vcvc_0, '0', lte_pre_decoder_vcvc_0, '0']
- [lte_pbch_demux_vcvc_0, '0', lte_pre_decoder_vcvc_1, '0']
- [lte_pbch_demux_vcvc_0_0, '0', lte_pre_decoder_vcvc_1, '2']
- [lte_pbch_demux_vcvc_0_1, '0', lte_pre_decoder_vcvc_0, '1']
- [lte_pbch_demux_vcvc_0_1, '0', lte_pre_decoder_vcvc_1, '1']
- [lte_pbch_descrambler_0, '0', pad_sink_0, '0']
- [lte_pre_decoder_vcvc_0, '0', pbch_layer_demapper_vcvc_0, '0']
- [lte_pre_decoder_vcvc_1, '0', pbch_layer_demapper_vcvc_1, '0']
- [pad_source_0, '0', lte_pbch_demux_vcvc_0, '0']
- [pad_source_1, '0', lte_pbch_demux_vcvc_0_1, '0']
- [pad_source_2, '0', lte_pbch_demux_vcvc_0_0, '0']
- [pbch_blocks_interleave_0, '0', pbch_qpsk_soft_demod_vcvf_0, '0']
- [pbch_layer_demapper_vcvc_0, '0', pad_sink_0_0, '0']
- [pbch_layer_demapper_vcvc_0, '0', pbch_blocks_interleave_0, '0']
- [pbch_layer_demapper_vcvc_1, '0', pbch_blocks_interleave_0, '1']
- [pbch_qpsk_soft_demod_vcvf_0, '0', lte_pbch_descrambler_0, '0']
- [z_pad_source_cell_id, out, lte_pbch_demux_vcvc_0, cell_id]
- [z_pad_source_cell_id, out, lte_pbch_demux_vcvc_0_0, cell_id]
- [z_pad_source_cell_id, out, lte_pbch_demux_vcvc_0_1, cell_id]
- [z_pad_source_cell_id, out, lte_pbch_descrambler_0, cell_id]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-128-gfa8953de
