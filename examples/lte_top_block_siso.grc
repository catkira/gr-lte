options:
  parameters:
    author: Johannes Demel
    category: Custom
    generate_options: qt_gui
    id: lte_top_block_siso
    output_language: python
    title: LTE top level flowgraph SISO
  states: {}

blocks:
- name: N_rb_dl
  id: variable
  parameters:
    value: '6'
  states: {}
- name: fftlen
  id: variable
  parameters:
    value: '256'
  states: {}
- name: frame_key
  id: variable
  parameters:
    value: '"slot"'
  states: {}
- name: interp_val
  id: variable
  parameters:
    value: int(samp_rate/1e4)
  states: {}
- name: pbch_descr_key
  id: variable
  parameters:
    value: '"descr_part"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (7*fftlen + 160* fftlen/2048 + 6 * (144 * fftlen/2048)) / 0.0005
  states: {}
- name: MIB
  id: lte_mib_unpack_vbm
  parameters:
    name: ' "mib_unpack_vbm"'
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-127'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-127'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_deinterleave_1
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * 2)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '8E-3'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '8e-3'
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: lte_bch_decoder_0
  id: lte_bch_decoder
  parameters: {}
  states: {state: disabled}
- name: lte_channel_estimator_0
  id: lte_channel_estimator
  parameters:
    N_rb_dl: N_rb_dl
    estimator_key: '"slot"'
    initial_id: '124'
  states: {state: disabled}
- name: lte_cp_ffo_sync_0
  id: lte_cp_ffo_sync
  parameters:
    fftlen: fftlen
    known_f_offset: '-20000'
  states: {}
- name: lte_ofdm_demodulator_0
  id: lte_ofdm_demodulator
  parameters:
    N_rb_dl: N_rb_dl
    fftlen: fftlen
    ofdm_key: '"slot"'
  states: {state: disabled}
- name: lte_pbch_decoder_0
  id: lte_pbch_decoder
  parameters:
    N_rb_dl: N_rb_dl
  states: {state: disabled}
- name: lte_pcfich_decoder_0
  id: lte_pcfich_decoder
  parameters:
    N_rb_dl: N_rb_dl
    key: '"slot"'
  states: {state: disabled}
- name: lte_pss_sync_0
  id: lte_pss_sync
  parameters:
    fftlen: fftlen
  states: {}
- name: lte_sss_sync_0
  id: lte_sss_sync
  parameters:
    N_rb_dl: N_rb_dl
    fftlen: fftlen
    group_key: '"N_id_2"'
    offset_key: '"offset_marker"'
  states: {}
- name: pre_blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/d/git/gr-lte/examples/recording3.840.dat
    length: '300000'
    repeat: 'False'
    type: complex
  states: {}
- name: pre_blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /mnt/d/f1860_s1.92_g0_1s_strong.bin
    length: '3840128'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: pre_rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1000'
    interp: interp_val
    taps: ''
    type: ccc
  states: {state: disabled}
- name: sync_lte_rough_symbol_sync_cc_0
  id: lte_rough_symbol_sync_cc
  parameters:
    fftl: fftlen
    name: ' "rough_symbol_sync_cc"'
    vlen: '1'
  states: {}

connections:
- [MIB, N_ant, lte_pcfich_decoder_0, N_ant]
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_0, '0', blocks_head_0_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_deinterleave_0, '0', blocks_add_xx_0, '1']
- [blocks_deinterleave_0, '1', blocks_add_xx_0, '0']
- [blocks_deinterleave_1, '0', blocks_uchar_to_float_0, '0']
- [blocks_deinterleave_1, '1', blocks_uchar_to_float_1, '0']
- [blocks_float_to_complex_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [blocks_head_0_0, '0', blocks_throttle_0, '0']
- [blocks_head_0_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_complex_0, '1']
- [blocks_throttle_0, '0', pre_rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_add_const_vxx_1, '0']
- [lte_bch_decoder_0, '0', MIB, '0']
- [lte_bch_decoder_0, '1', MIB, '1']
- [lte_channel_estimator_0, '0', lte_pbch_decoder_0, '0']
- [lte_channel_estimator_0, '0', lte_pcfich_decoder_0, '0']
- [lte_channel_estimator_0, '1', lte_pbch_decoder_0, '1']
- [lte_channel_estimator_0, '1', lte_pcfich_decoder_0, '1']
- [lte_cp_ffo_sync_0, '0', blocks_null_sink_0, '0']
- [lte_cp_ffo_sync_0, '0', lte_sss_sync_0, '0']
- [lte_ofdm_demodulator_0, '0', lte_channel_estimator_0, '0']
- [lte_ofdm_demodulator_0, '0', lte_pbch_decoder_0, '2']
- [lte_ofdm_demodulator_0, '0', lte_pcfich_decoder_0, '2']
- [lte_pbch_decoder_0, '0', lte_bch_decoder_0, '0']
- [lte_pss_sync_0, '0', blocks_null_sink_0_0_0, '0']
- [lte_pss_sync_0, '0', lte_cp_ffo_sync_0, '0']
- [lte_sss_sync_0, '0', blocks_null_sink_0_0, '0']
- [lte_sss_sync_0, '0', lte_ofdm_demodulator_0, '0']
- [lte_sss_sync_0, cell_id, lte_channel_estimator_0, cell_id]
- [lte_sss_sync_0, cell_id, lte_pbch_decoder_0, cell_id]
- [lte_sss_sync_0, cell_id, lte_pcfich_decoder_0, cell_id]
- [pre_blocks_file_source_0, '0', blocks_deinterleave_0, '0']
- [pre_blocks_file_source_0, '0', blocks_head_0_0, '0']
- [pre_blocks_file_source_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [pre_blocks_file_source_0_0, '0', blocks_deinterleave_1, '0']
- [pre_rational_resampler_xxx_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [sync_lte_rough_symbol_sync_cc_0, '0', lte_pss_sync_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-128-gfa8953de
